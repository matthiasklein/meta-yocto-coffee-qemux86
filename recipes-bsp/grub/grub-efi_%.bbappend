# add more commands for grub.cfg
GRUB_BUILDIN:append = " hashsum eval echo cat reboot sleep read"

